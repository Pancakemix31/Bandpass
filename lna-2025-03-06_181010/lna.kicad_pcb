# Repository Pancakemix31/Bandpass

## KiCad design lna-2025-03-06_181010/lna.kicad_pcb

Board: 2 copper layers, 35.0 x 20.0 mm, 18 parts (0 on the bottom side), 11 nets.

Parts:
C1: 8pF; C_0603_1608Metric
C2: 2.7pF; C_0603_1608Metric
C3: 330pF; C_0603_1608Metric
C4, C7: 100pF; C_0603_1608Metric
C5: 100nF; C_0603_1608Metric
C6: 10uF; CP_EIA-3216-18_Kemet-A
FB1: 600R/0.5A; Murata-BLM18-0.15-t0.8-0-0-IPC_A
J1, J3: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
J2: V5-GND; PinHeader_1x02_P2.54mm_Vertical
L1: 200nH; L_0805_2012Metric
L2: 560nH; L_0805_2012Metric
L3, L5: 220nH; L_0805_2012Metric
L4: 390nH; L_0805_2012Metric
R1: 120R; R_0603_1608Metric
U1: PGA-103+; SOT-89-3

Connections:
5V: FB1.1, J2.2 (5V)
GND: C1.2, C3.2, C4.1, C5.2, C6.2, J1.2 (Ext), J2.1 (GND), J3.2 (Ext), L1.2, U1.2 (GND)
unnamed: C2.2, L2.2
unnamed: C3.1, R1.2
unnamed: C4.2, C5.1, C6.1, FB1.2, L5.2
unnamed: C7.1, L5.1, U1.3
unnamed: C1.1, C2.1, J1.1 (In), L1.1
unnamed: C7.2, J3.1 (In)
unnamed: L2.1, L3.1, U1.1
unnamed: L3.2, L4.1
unnamed: L4.2, R1.1
